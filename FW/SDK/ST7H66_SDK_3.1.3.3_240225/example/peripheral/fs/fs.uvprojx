# Keil uVision project fs.uvprojx, settings and files
target fs (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: fs +hex
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/fs.axf
  AfterMake: fromelf.exe .\Objects\fs.axf --i32combined --output .\bin\fs.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP HCI_TL_NONE=1 OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 MAIN_HAS_NOARGC MAIN_HAS_NORETURN DEBUG_INFO=1 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;.\source;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\arch\cm0;..\..\..\components\ble\include;..\..\..\components\ble\controller;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\libraries\secure;..\..\..\components\osal\include;..\..\..\misc;..\..\..\components\driver\uart;..\..\..\components\driver\log;..\..\..\components\driver\adc;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\timer;..\..\..\components\driver\spi;..\..\..\components\libraries\cli;..\..\..\components\driver\pwm;..\..\..\components\driver\kscan;..\..\..\components\driver\dma;..\..\..\components\driver\flash;..\..\..\components\driver\spiflash;..\..\..\components\driver\watchdog;.\source;..\..\..\components\driver\adc;..\..\..\components\libraries\fs;..\..\..\components\libraries\crc16;..\..\..\components\driver\flash;..\..\..\components\libraries\fs
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff1000 size 0x3800
  scatter file: .\fs.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group main
    ./source/: main.c fs_demo.c fs_Main.c OSAL_fs.c
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/timer/: timer.c
    ../../../components/libraries/fs/: fs.c fs_autotest.c fs_autotest.h fs_test.c fs_shadow.c fsr_raid.c
    ../../../components/libraries/crc16/: crc16.c
    ../../../components/driver/flash/: flash.c
  group jump
    ../../../misc/: jump_table.c
  group rf
    ../../../lib/: rf.lib
  group coremark
    ../../../components/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group cli
    ../../../components/libraries/cli/: cliface.c cliface.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
