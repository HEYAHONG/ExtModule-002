# Keil uVision project pwmLight.uvprojx, settings and files
target pwmLight (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: pwmLight +hex
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/pwmLight.axf
  AfterMake: fromelf.exe .\Objects\pwmLight.axf --i32combined --output .\bin\pwmLight.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP HOST_CONFIG=4 HCI_TL_NONE=1 MTU_SIZE=247 ENABLE_LOG_ROM_=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEBUG_INFO=1 USE_SYS_TICK HUGE_MODE=0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\common;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\ota_app;..\..\..\components\profiles\hrs;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\uart;..\..\..\components\driver\i2c;..\..\..\components\driver\adc;..\..\..\components\driver\clock;..\..\..\components\driver\pwm;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\libraries\console;..\..\..\components\libraries\fs;..\..\..\components\libraries\datetime;..\..\..\lib;.\Source;.\Source\ble;..\..\..\misc;..\..\..\components\arch\cm0;..\..\..\components\ble\controller;..\..\..\components\driver\led_light;..\..\..\components\libraries\crc16;..\..\..\components\libraries\cli
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/Roles/: gap.c gapgattserver.c peripheral.c gapbondmgr.c
    ../../../components/profiles/ota_app/: ota_app_service.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: OSAL_wrist.c app_wrist.c wrist_Main.c
    ./Source/ble/: wristservice.c
    ../../../components/driver/led_light/: led_light.c
  group lib
    ../../../lib/: ble_host.lib rf.lib
    ../../../components/libraries/ll_patch/: ll_patch.c
  group driver
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/i2c/: i2c.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/kscan/: kscan.c
    ../../../components/driver/flash/: flash.c
  group library
    ../../../components/libraries/console/: phy_console.c
    ../../../components/libraries/datetime/: app_datetime.c
    ../../../components/osal/snv/: osal_snv.c
  group fs
    ../../../components/libraries/fs/: fs.c
  group fs2
    ../../../components/libraries/fs2/: fs.c
  group crc16
    ../../../components/libraries/crc16/: crc16.c crc16.h
  group cli
    ../../../components/libraries/cli/: cliface.c cliface.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
