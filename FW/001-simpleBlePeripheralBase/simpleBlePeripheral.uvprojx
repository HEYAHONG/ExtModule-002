# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target ST17H66 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  AfterMake: fromelf -c -a -d -e -v -o simpleBlePeripheral.asm ./Objects/simpleBlePeripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP CFG_HCLK_DYNAMIC_CHANGE=0 DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DPB_C99_STATIC_ASSERT=1  -DHBOX_CONFIG_HEADER=hbox_config.h  -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\SDK\ST7H66_SDK_3.1.3.3_240225\components\inc;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\ble\controller;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\osal\include;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\common;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\ble\include;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\ble\hci;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\ble\host;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\Profiles\ota_app;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\Profiles\DevInfo;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\Profiles\SimpleProfile;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\Profiles\Roles;.\source;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\libraries\crc16;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\libraries\ll_patch;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\watchdog;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\clock;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\arch\cm0;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\pwrmgr;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\uart;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\gpio;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\timer;..\SDK\ST7H66_SDK_3.1.3.3_240225\misc;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\log;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\libraries\cliface;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\key;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\pwm;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\flash;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\libraries\fs;..\SDK\ST7H66_SDK_3.1.3.3_240225\components\driver\led_light;..\3rdparty\HCppBox\master\hbox;..\3rdparty\HCppBox\master\hbox\cpp;..\3rdparty\HCppBox
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\SDK\ST7H66_SDK_3.1.3.3_240225\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/uart/: uart.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/clock/: clock.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/gpio/: gpio.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/timer/: timer.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/watchdog/: watchdog.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/pwrmgr/: pwrmgr.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/log/: my_printf.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/key/: key.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/pwm/: pwm.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/osal/snv/: osal_snv.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/flash/: flash.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/driver/led_light/: led_light.c
  group profile
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/profiles/GATT/: gattservapp.c
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/profiles/ota_app/: ota_app_service.c
    ./source/: sbpProfile_ota.c
  group jump
    ../SDK/ST7H66_SDK_3.1.3.3_240225/misc/: jump_table.c
  group lib
    ../SDK/ST7H66_SDK_3.1.3.3_240225/lib/: rf.lib ble_host.lib
    ../SDK/ST7H66_SDK_3.1.3.3_240225/components/libraries/ll_patch/: ll_patch.c
  group simpleBlePeripheral
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c devinfoservice.c led.c
  group HBox
    ../3rdparty/HCppBox/master/hbox/: h3rdparty.c h3rdparty_cjson.c h3rdparty_cjsonutils.c h3rdparty_mqtt_packet.c h3rdparty_pb_common.c h3rdparty_pb_decode.c h3rdparty_pb_encode.c h3rdparty_printf.c h3rdparty_softfloat.c h3rdparty_softfp.c hbase64.c hcompiler.c hdefaults.c heventchain.c heventloop.c heventslots.c hmemoryheap.c hobject.c hringbuf.c hsimulator.c hstacklesscoroutine.c hunicode.c hwatchdog.c hgui.c hmodbus.c hshell.c huuid.c hcrypto.c hruntime.c
    ../3rdparty/HCppBox/: hbox_config.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
